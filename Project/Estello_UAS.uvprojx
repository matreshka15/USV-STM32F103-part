# Keil uVision project Estello_UAS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UAS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STD_DRIVER
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c stm32f10x_dma.c
  group RVMDK
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../User/: system_stm32f10x.c
  group PHYSIC_LAYER
    ../User/COMPASS/: COMPASS.c
    ../User/EXT/: ext.c
    ../User/GPS/: GPS.c
    ../User/IMU/: IMU.c
    ../User/Motor/: Motor.c
    ../User/Usart/: USART.c
    ../User/TD/: TD.c
    ../User/GeneralFunction/: General_fucntion.c
    ../User/PWM/: pwm.c
    ../User/WirelessUSART/: WirelessPort.c
  group CORE_LAYER
    ../User/: main.c stm32f10x_it.c initialize.c
    ../User/IIC/: IIC.c
    ../User/LoopSequence/: Loop.c
    ../User/RingBuff/: ring_buff.c
    ../User/FILTER/: FILTER.c
    ../User/DATAFUSION/: DATAFUSION.c
    ../User/Delay/: delay.c
    ../User/PID/: PID.c
    ../User/PathPlanning/: PathPlanning.c
    ../User/WDG/: WDG.c
    ../User/INPUT_CAPTURE/: INPUT_CAPTURE.c
